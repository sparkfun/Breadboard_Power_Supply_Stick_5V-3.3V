# Repository sparkfun/Breadboard_Power_Supply_Stick_5V-3.3V

File README.md:

SparkFun Breadboard Power Supply Stick 5V/3.3V
===============================================

[*SparkFun Breadboard Power Supply Stick 5V/3.3V(PRT-13032)*](https://www.sparkfun.com/products/13032)

This is a very simple board that takes a 6-12V input voltage and outputs a selectable 5V or 3.3V regulated voltage. 
All headers are 0.1" pitch for simple insertion into a breadboard.

Repository Contents
-------------------
* **/Hardware** - All hardware files for Breadboard Power Supply
* **/Production** - Test bed files and production panel files

Product Versions
----------------
* [PRT-13032](https://www.sparkfun.com/products/13032)- Version 1.4. Currently available.
* [PRT-10804](https://www.sparkfun.com/products/10804)- Version 1.3. Retired. 

Version History
---------------
* [v_14](https://github.com/sparkfun/Breadboard_Power_Supply_Stick_5V-3.3V/tree/v_14)- GitHub files, version 1.4
* [v13](https://github.com/sparkfun/Breadboard_Power_Supply_Stick_5V-3.3V/tree/v13) - GitHub files, version 1.3

License Information
-------------------
The hardware is released under [Creative Commons ShareAlike 4.0 International](https://creativecommons.org/licenses/by-sa/4.0/).

Distributed as-is; no warranty is given.

## EAGLE design Hardware/Breadboard Power Supply - SMD.brd

Parts:
C1: 100uF; EIA7343
C2: 10uF; EIA3216
C3: 0.1uF; 0603-CAP
D1: 1N4001; SMA-DIODE-TYLERALT1
F1: PTCSMD-W; PTC-1206-WIDE
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1: POWER_JACKSMD; POWER_JACK_SMD
JP1, JP2, JP3, JP4, JP6, JP7, JP8, JP9: M01PTH; 1X01
JP5: M02PTH; 1X02
LED2: Power; LED-1206
LOGO1: OSHW-LOGOS; OSHW-LOGO-S
R1: 240; 0603-RES
R2: 390; 0603-RES
R3, R4: 330; 0603-RES
S1: On/Off; AYZ0202
S2: Voltage; AYZ0202
U1: V_REG_317SMD; SOT223
U$1: LOGO-SFESK; SFE-LOGO-FLAME
U$2: LOGO-SFENEW; SFE-NEW-WEBLOGO
U$3, U$4: FIDUCIAL1X2; FIDUCIAL-1X2

Connections:
GND: C1.C (-), C2.C (-), C3.2, J1.GND (GNDBREAK), J1.P$4 (GND), JP1.1, JP4.1, JP5.2, JP6.1, JP9.1, LED2.C, R3.1, S2.3 (S)
unnamed: D1.C, F1.1
unnamed: D1.A, S1.1 (3), S1.4 (6)
unnamed: R2.1, R3.2, S2.2
unnamed: R1.1, R2.2, U1.1 (ADJ)
unnamed: LED2.A, R4.1
RAW: C1.A (+), F1.2, U1.3 (IN)
VCC: C2.A (+), C3.1, JP2.1, JP3.1, JP7.1, JP8.1, R1.2, R4.2, U1.2 (OUT)
VIN: J1.VIN0 (PWR), JP5.1, S1.2, S1.5

Notes on the sheet:
Grounded: 3.3V
Open: 5V
N. Seidle
Revised by: Patrick Alberts

Board: 2 copper layers, 54.6 x 16.5 mm, 29 parts (1 on the bottom side), 9 nets.

## EAGLE design Production/Breadboard Power Supply - SMD-Panel-v14.brd

Board: 2 copper layers, 123.4 x 115.3 mm, 339 parts (12 on the bottom side), 108 nets.

Parts:
C1, C4, C7, C10, C13, C16, C19, C22, C25, C28, C31, C34: 100uF; EIA7343
C2, C5, C8, C11, C14, C17, C20, C23, C26, C29, C32, C35: 10uF; EIA3216
C3, C6, C9, C12, C15, C18, C21, C24, C27, C30, C33, C36: 0.1uF; 0603-CAP
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 1N4001; SMA-DIODE-TYLERALT1
E$1: FIDUCIAL-1.5X3
E$4, E$6: FIDUCIAL-1X2
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12: PTCSMD-W; PTC-1206-WIDE
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: POWER_JACKSMD; POWER_JACK_SMD
JP1, JP2, JP3, JP4, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP15, JP16, JP17, JP18, JP19, JP20, JP21, JP22, JP24, JP25, JP26, JP27, JP28, JP29, JP30, JP31, JP33, JP34, JP35, JP36, JP37, JP38, JP39, JP40, JP42, JP43, JP44, JP45, JP46, JP47, JP48, JP49, JP51, JP52, JP53, JP54, JP55, JP56, JP57, JP58, JP60, JP61, JP62, JP63, JP64, JP65, JP66, JP67, JP69, JP70, JP71, JP72, JP73, JP74, JP75, JP76, JP78, JP79, JP80, JP81, JP82, JP83, JP84, JP85, JP87, JP88, JP89, JP90, JP91, JP92, JP93, JP94, JP96, JP97, JP98, JP99, JP100, JP101, JP102, JP103, JP105, JP106, JP107, JP108: M01PTH; 1X01
JP5, JP14, JP23, JP32, JP41, JP50, JP59, JP68, JP77, JP86, JP95, JP104: 1X02
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: Power; LED-1206
LOGO1, LOGO2, LOGO3, LOGO4, LOGO5, LOGO6, LOGO7, LOGO8, LOGO9, LOGO10, LOGO11, LOGO12: OSHW-LOGOS; OSHW-LOGO-S
R1, R6, R10, R14, R18, R22, R26, R30, R34, R38, R42, R46: 240; 0603-RES
R2, R5, R9, R13, R17, R21, R25, R29, R33, R37, R41, R45: 390; 0603-RES
R3, R4, R7, R8, R11, R12, R15, R16, R19, R20, R23, R24, R27, R28, R31, R32, R35, R36, R39, R40, R43, R44, R47, R48: 330; 0603-RES
S1, S4, S6, S8, S10, S12, S14, S16, S18, S20, S22, S24: On/Off; AYZ0202
S2, S3, S5, S7, S9, S11, S13, S15, S17, S19, S21, S23: Voltage; AYZ0202
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12: V_REG_317SMD; SOT223
U$1, U$5, U$9, U$13, U$17, U$21, U$25, U$29, U$33, U$37, U$41, U$45: LOGO-SFESK; SFE-LOGO-FLAME
U$2, U$6, U$10, U$14, U$18, U$22, U$26, U$30, U$34, U$38, U$42, U$46: LOGO-SFENEW; SFE-NEW-WEBLOGO
U$3, U$4, U$7, U$8, U$11, U$12, U$15, U$16, U$19, U$20, U$23, U$24, U$27, U$28, U$31, U$32, U$35, U$36, U$39, U$40, U$43, U$44, U$47, U$48: FIDUCIAL1X2; FIDUCIAL-1X2

Connections:
GND: C1.C, C2.C, C3.2, J1.GND, J1.P$4, JP1.1, JP4.1, JP5.2, JP6.1, JP9.1, LED2.C, R3.1, S2.3
GND1: C4.C, C5.C, C6.2, J2.GND, J2.P$4, JP10.1, JP13.1, JP14.2, JP15.1, JP18.1, LED1.C, R8.1, S3.3
GND2: C7.C, C8.C, C9.2, J3.GND, J3.P$4, JP19.1, JP22.1, JP23.2, JP24.1, JP27.1, LED3.C, R12.1, S5.3
GND3: C10.C, C11.C, C12.2, J4.GND, J4.P$4, JP28.1, JP31.1, JP32.2, JP33.1, JP36.1, LED4.C, R16.1, S7.3
GND4: C13.C, C14.C, C15.2, J5.GND, J5.P$4, JP37.1, JP40.1, JP41.2, JP42.1, JP45.1, LED5.C, R20.1, S9.3
GND5: C16.C, C17.C, C18.2, J6.GND, J6.P$4, JP46.1, JP49.1, JP50.2, JP51.1, JP54.1, LED6.C, R24.1, S11.3
GND6: C19.C, C20.C, C21.2, J7.GND, J7.P$4, JP55.1, JP58.1, JP59.2, JP60.1, JP63.1, LED7.C, R28.1, S13.3
GND7: C22.C, C23.C, C24.2, J8.GND, J8.P$4, JP64.1, JP67.1, JP68.2, JP69.1, JP72.1, LED8.C, R32.1, S15.3
GND8: C25.C, C26.C, C27.2, J9.GND, J9.P$4, JP73.1, JP76.1, JP77.2, JP78.1, JP81.1, LED9.C, R36.1, S17.3
GND9: C28.C, C29.C, C30.2, J10.GND, J10.P$4, JP82.1, JP85.1, JP86.2, JP87.1, JP90.1, LED10.C, R40.1, S19.3
GND10: C31.C, C32.C, C33.2, J11.GND, J11.P$4, JP91.1, JP94.1, JP95.2, JP96.1, JP99.1, LED11.C, R44.1, S21.3
GND11: C34.C, C35.C, C36.2, J12.GND, J12.P$4, JP100.1, JP103.1, JP104.2, JP105.1, JP108.1, LED12.C, R48.1, S23.3
unnamed: D1.C, F1.1
unnamed: D1.A, S1.1, S1.4
unnamed: R5.2, R6.1, U2.1
unnamed: R2.1, R3.2, S2.2
unnamed: R1.1, R2.2, U1.1
unnamed: LED1.A, R7.1
unnamed: D2.C, F2.1
unnamed: LED2.A, R4.1
unnamed: D2.A, S4.1, S4.4
unnamed: R5.1, R8.2, S3.2
unnamed: R9.2, R10.1, U3.1
unnamed: LED3.A, R11.1
unnamed: D3.C, F3.1
unnamed: D3.A, S6.1, S6.4
unnamed: R9.1, R12.2, S5.2
unnamed: R13.2, R14.1, U4.1
unnamed: LED4.A, R15.1
unnamed: D4.C, F4.1
unnamed: D4.A, S8.1, S8.4
unnamed: R13.1, R16.2, S7.2
unnamed: R17.2, R18.1, U5.1
unnamed: LED5.A, R19.1
unnamed: D5.C, F5.1
unnamed: D5.A, S10.1, S10.4
unnamed: R17.1, R20.2, S9.2
unnamed: R21.2, R22.1, U6.1
unnamed: LED6.A, R23.1
unnamed: D6.C, F6.1
unnamed: D6.A, S12.1, S12.4
unnamed: R21.1, R24.2, S11.2
unnamed: R25.2, R26.1, U7.1
unnamed: LED7.A, R27.1
unnamed: D7.C, F7.1
unnamed: D7.A, S14.1, S14.4
unnamed: R25.1, R28.2, S13.2
unnamed: R29.2, R30.1, U8.1
unnamed: LED8.A, R31.1
unnamed: D8.C, F8.1
unnamed: D8.A, S16.1, S16.4
unnamed: R29.1, R32.2, S15.2
unnamed: R33.2, R34.1, U9.1
unnamed: LED9.A, R35.1
unnamed: D9.C, F9.1
unnamed: D9.A, S18.1, S18.4
unnamed: R33.1, R36.2, S17.2
unnamed: R37.2, R38.1, U10.1
unnamed: LED10.A, R39.1
unnamed: D10.C, F10.1
unnamed: D10.A, S20.1, S20.4
unnamed: R37.1, R40.2, S19.2
unnamed: R41.2, R42.1, U11.1
unnamed: LED11.A, R43.1
unnamed: D11.C, F11.1
unnamed: D11.A, S22.1, S22.4
unnamed: R41.1, R44.2, S21.2
unnamed: R45.2, R46.1, U12.1
unnamed: LED12.A, R47.1
unnamed: D12.C, F12.1
unnamed: D12.A, S24.1, S24.4
unnamed: R45.1, R48.2, S23.2
RAW: C1.A, F1.2, U1.3
RAW1: C4.A, F2.2, U2.3
RAW2: C7.A, F3.2, U3.3
RAW3: C10.A, F4.2, U4.3
RAW4: C13.A, F5.2, U5.3
RAW5: C16.A, F6.2, U6.3
RAW6: C19.A, F7.2, U7.3
RAW7: C22.A, F8.2, U8.3
RAW8: C25.A, F9.2, U9.3
RAW9: C28.A, F10.2, U10.3
RAW10: C31.A, F11.2, U11.3
RAW11: C34.A, F12.2, U12.3
VCC: C2.A, C3.1, JP2.1, JP3.1, JP7.1, JP8.1, R1.2, R4.2, U1.2
VCC1: C5.A, C6.1, JP11.1, JP12.1, JP16.1, JP17.1, R6.2, R7.2, U2.2
VCC2: C8.A, C9.1, JP20.1, JP21.1, JP25.1, JP26.1, R10.2, R11.2, U3.2
VCC3: C11.A, C12.1, JP29.1, JP30.1, JP34.1, JP35.1, R14.2, R15.2, U4.2
VCC4: C14.A, C15.1, JP38.1, JP39.1, JP43.1, JP44.1, R18.2, R19.2, U5.2
VCC5: C17.A, C18.1, JP47.1, JP48.1, JP52.1, JP53.1, R22.2, R23.2, U6.2
VCC6: C20.A, C21.1, JP56.1, JP57.1, JP61.1, JP62.1, R26.2, R27.2, U7.2
VCC7: C23.A, C24.1, JP65.1, JP66.1, JP70.1, JP71.1, R30.2, R31.2, U8.2
VCC8: C26.A, C27.1, JP74.1, JP75.1, JP79.1, JP80.1, R34.2, R35.2, U9.2
VCC9: C29.A, C30.1, JP83.1, JP84.1, JP88.1, JP89.1, R38.2, R39.2, U10.2
VCC10: C32.A, C33.1, JP92.1, JP93.1, JP97.1, JP98.1, R42.2, R43.2, U11.2
VCC11: C35.A, C36.1, JP101.1, JP102.1, JP106.1, JP107.1, R46.2, R47.2, U12.2
VIN: J1.VIN0, JP5.1, S1.2, S1.5
VIN1: J2.VIN0, JP14.1, S4.2, S4.5
VIN2: J3.VIN0, JP23.1, S6.2, S6.5
VIN3: J4.VIN0, JP32.1, S8.2, S8.5
VIN4: J5.VIN0, JP41.1, S10.2, S10.5
VIN5: J6.VIN0, JP50.1, S12.2, S12.5
VIN6: J7.VIN0, JP59.1, S14.2, S14.5
VIN7: J8.VIN0, JP68.1, S16.2, S16.5
VIN8: J9.VIN0, JP77.1, S18.2, S18.5
VIN9: J10.VIN0, JP86.1, S20.2, S20.5
VIN10: J11.VIN0, JP95.1, S22.2, S22.5
VIN11: J12.VIN0, JP104.1, S24.2, S24.5

## Commit log

2013-07-16 Initial Board eagle files
    v13
2013-08-01 Adjusted MBRA140, PTC fuse, Barrel jack new pads
    all footprints committed to testing lbr. added .gitignore
2013-08-01 Updated frame, rerouted traces, added OSHW
2013-08-20 readme cleanup and hardware folder
2013-08-28 Fixed Review Issues
    Added extra VCC and GND headers for stability. spaced out res along top
    edge. removed weird tDocu lines. cleaned up repo
2014-01-16 Updated Footprints
    Updated footprints on the Diode/PTC/BarrelJack
2014-01-21 Added Board Name
2014-05-14 fixed board name
2014-08-07 Updating to current files
2014-08-07 Adding new rev files back in
2014-08-08 created panel v14
2015-03-12 Updating README

Notices in the files:
parts and their libraries:
SparkFun-Aesthetics: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 3.0 License
SparkFun-Aesthetics: http://creativecommons.org/licenses/by-sa/3.0
